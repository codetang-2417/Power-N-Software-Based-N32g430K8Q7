# Keil uVision project PowerMeter.uvprojx, settings and files
target PowerMeter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: N32G430K8Q7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PowerMeter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SystemCoreClock
  c include: .\BSP\inc;.\firmware\n32g430_std_periph_driver\inc;.\firmware\CMSIS\device;.\firmware\CMSIS\core;.\Hardware\ADC;.\Hardware\LCD;.\Hardware\SPI;.\Hardware\KEY;.\Hardware\SYSCLK;.\Hardware\MENU\inc;.\Hardware\FS2711;.\Hardware\I2C;.\Hardware\DECOY;.\Hardware\FLASH
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ./firmware/CMSIS/device/startup/: startup_n32g430.s
  group BSP
    ./BSP/: bsp_delay.c
  group FWLIB
    ./firmware/n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_beeper.c n32g430_can.c n32g430_comp.c n32g430_crc.c n32g430_dbg.c n32g430_dma.c n32g430_exti.c n32g430_flash.c n32g430_gpio.c n32g430_i2c.c n32g430_iwdg.c n32g430_lptim.c n32g430_pwr.c n32g430_rcc.c n32g430_rtc.c n32g430_spi.c n32g430_tim.c n32g430_usart.c n32g430_wwdg.c
  group CMSIS
    ./firmware/CMSIS/device/: system_n32g430.c
  group User
    ./usr/: main.c
    ./BSP/: n32g430_it.c
  group HARDWARE
    ./Hardware/LCD/: lcd.c lcd_init.c
    ./Hardware/ADC/: adc.c
    ./Hardware/SPI/: spi.c
    ./Hardware/FS2711/: FS2711.c
    ./Hardware/I2C/: i2c.c
    ./Hardware/FLASH/: flash.c
  group KEY
    ./Hardware/KEY/: key.c keyio.c
  group SYSCLK
    ./Hardware/SYSCLK/: sysclk.c
  group MENU
    ./Hardware/MENU/src/: menu.c ui.c ui_measure.c ui_adjust.c
    ./Hardware/DECOY/: decoy.c
